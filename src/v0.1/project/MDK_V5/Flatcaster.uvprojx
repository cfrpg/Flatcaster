# Keil uVision project Flatcaster.uvprojx, settings and files
target Flatcaster (6230000::V6.23::ARMCLANG)
  device: -AT32F435RMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flatcaster +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F435RMT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\src\sys;..\src\drivers;..\src\module;..\src\tools
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c main.c wk_adc.c wk_dac.c wk_qspi.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_ertc.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_edma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_crc.c at32f435_437_wwdt.c at32f435_437_wdt.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_can.c at32f435_437_dac.c at32f435_437_xmc.c at32f435_437_qspi.c at32f435_437_sdio.c at32f435_437_dvp.c at32f435_437_emac.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group sys
    ../src/sys/: delay.c delay.h sys_config.c sys_config.h
  group drivers
    ../src/drivers/: debug_usart.c debug_usart.h timer.c timer.h led.c led.h flash.c flash.h max98357a.c max98357a.h touch.c touch.h adc.c adc.h
  group module
    ../src/module/: parameter.c parameter.h parameterList.c parameterRef.c pptlink.c pptlink.h ks_engine.c ks_engine.h ks_data.c midi.c midi.h
  group tools
    ../src/tools/: signalGen.c signalGen.h mathHelper.c mathHelper.h
